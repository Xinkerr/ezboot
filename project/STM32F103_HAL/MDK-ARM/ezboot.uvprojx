# Keil uVision project ezboot.uvprojx, settings and files
target ezboot (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ezboot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../config;../porting/mcu_header;../../../components/boot/inc;../../../components/crypt/inc;../../../components/ezb_flash/inc;../../../components/mlog/inc;../../../components/norflash/inc;../../../components/ota/inc;../../../components/ota_mgr/inc
  memory RVCT4: ROM 0x8000000 size 0x3800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group porting
    ../porting/ezb_flash/: ezb_flash.c
    ../porting/mcu_header/: mcu_header.h
    ../porting/mlog/: mlog_uart.c
    ../porting/norflash/: norflash_spi.c
    ../config/: ezboot_config.h
  group components
    ../../../components/boot/src/: boot.c
    ../../../components/crypt/src/: aes_decrypt.c aes_encrypt.c cbc_mode.c image_decrypt.c sha256.c utils.c
    ../../../components/mlog/src/: mlog.c
    ../../../components/norflash/src/: norflash.c
    ../../../components/ota/src/: ota.c
    ../../../components/ota_mgr/src/: ota_mgr_nvs.c
    ../../../: main.c
software components: CMSIS:CORE 4.3.0
