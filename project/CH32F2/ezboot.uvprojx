# Keil uVision project ezboot.uvprojx, settings and files
target ezboot (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: CH32F203CB WCH
  pack: Keil.WCH32F2xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ezboot +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\SRC\StdPeriphDriver\inc;.\SRC\CMSIS;.\chip;..\..\components\mlog\inc;..\..\components\boot\inc;..\..\components\ota_mgr\inc;..\..\components\sfud\inc;..\..\components\ota\inc;.\config;.\porting\mcu_header;..\..\components\crypt\inc;..\..\components\ezb_flash\inc;..\..\components\norflash\inc
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../../: main.c
    ./chip/: ch32f20x_it.c system_ch32f20x.c
    ./config/: ezboot_config.h
  group startup
    ./SRC/Startup/: startup_ch32f20x_D6.s
  group core
    ./SRC/CMSIS/: core_cm3.c
  group peripheral
    ./SRC/StdPeriphDriver/src/: ch32f20x_adc.c ch32f20x_bkp.c ch32f20x_can.c ch32f20x_crc.c ch32f20x_dac.c ch32f20x_dbgmcu.c ch32f20x_dma.c ch32f20x_dvp.c ch32f20x_eth.c ch32f20x_exti.c ch32f20x_flash.c ch32f20x_fsmc.c ch32f20x_gpio.c ch32f20x_i2c.c ch32f20x_iwdg.c ch32f20x_misc.c ch32f20x_opa.c ch32f20x_pwr.c ch32f20x_rcc.c ch32f20x_rng.c ch32f20x_rtc.c ch32f20x_sdio.c ch32f20x_spi.c ch32f20x_tim.c ch32f20x_usart.c ch32f20x_wwdg.c
  group components
    ../../components/mlog/src/: mlog.c
    ../../components/mlog/inc/: mlog.h
    ../../components/ota/src/: ota.c
    ../../components/boot/src/: boot.c
    ../../components/crypt/src/: aes_decrypt.c sha256.c utils.c image_decrypt.c cbc_mode.c aes_encrypt.c
    ../../components/ezb_flash/inc/: ezb_flash.h
    ../../components/ota_mgr/src/: ota_mgr_nvs.c
    ../../components/norflash/src/: norflash.c
  group porting
    ./porting/mlog/: mlog_uart.c
    ./porting/ezb_flash/: ezb_flash.c
    ./porting/norflash/: norflash_spi.c
